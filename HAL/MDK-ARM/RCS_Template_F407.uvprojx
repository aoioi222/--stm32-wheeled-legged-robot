# Keil uVision project RCS_Template_F407.uvprojx, settings and files
target RCS_Template_F407 (6240000::V6.24::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: RCS_Template_F407 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: -fno-fast-math
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../RCS/RCS_HAL/inc;../RCS/RCS_Support/inc;../RCS/RCS_Module/inc;../RCS/RCS_Module/inc/rcs_actor;..\RCS\ThirdParty_Module\OLED;../RCS/RCS_Template;../RCS/user;../RCS/user/robot;../RCS/user/robot/Motor;../RCS/user/robot/IMU;../RCS/user/robot/Calculate;../RCS/user/robot/gait_controller;../RCS/user/robot/remote_controller
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group RCS/user
    ../RCS/user/: upctrl_fsm.cpp
  group Robot
    ../RCS/user/robot/: bezier_foot_tra.c bezier_foot_tra.h body_control.c body_control.h Foot_mode_control.c Foot_mode_control.h Foot_structure.c Foot_structure.h gravity_comp.c gravity_comp.h include_head.h Kalman_Filter.c Kalman_Filter.h RCS_PIDctrl.c RCS_PIDctrl.h robot_config.h robot_math.h robot_state.c robot_state.h robot_task.c Wheel_mode_contrl.c Wheel_mode_contrl.h
  group Robot/Motor
    ../RCS/user/robot/Motor/: dm_h6215.c dm_h6215.h edulite05.c edulite05.h motor_can_hal.c motor_can_hal.h
  group Robot/IMU
    ../RCS/user/robot/IMU/: I2C_ICM_42688_P_control.c I2C_ICM_42688_P_control.h ICM_42688_P_RegAddress.h
  group Robot/Calculate
    ../RCS/user/robot/Calculate/: Forward_kinematics_calculate.c Forward_kinematics_calculate.h Inverse_kinematics_calculate.c Inverse_kinematics_calculate.h Jacobian_matrix.c Jacobian_matrix.h
  group Robot/gait_controller
    ../RCS/user/robot/gait_controller/: gait_controller.c gait_controller.h gait_generator.c gait_generator.h gait_scheduler.c gait_scheduler.h leg_state_machine.c leg_state_machine.h
  group Robot/remote_controller
    ../RCS/user/robot/remote_controller/: jump_controller.c jump_controller.h rc_event_dispatch.c rc_event_dispatch.h remote_control_sbus.c remote_control_sbus.h robot_sbus.c robot_sbus.h
  group RCS/Template
    ../RCS/RCS_Template/: rmmotor_test.cpp freertos_kprintf_test.c cylinder_test.cpp uart_test.c upctrl_test.cpp gps_local.cpp
  group RCS/Module
    ../RCS/RCS_Module/src/rcs_actor/: rcs_motor_gm6020.cpp rcs_motor_rm3508.cpp rcs_cylinder.cpp
    ../RCS/RCS_Module/src/: rcs_actor_bus.cpp rcs_gyro.cpp rm_motor_raw.c
  group RCS/Support
    ../RCS/RCS_Support/src/: siso_fifo.c sync_pid.cpp kin_chassis.cpp path_planning.cpp gps.cpp easy_filters.c rdlc.c
    ../RCS/RCS_Support/inc/: angle_loop.h
  group RCS/HAL
    ../RCS/RCS_HAL/src/: rcs_adc.c rcs_gpio.c rcs_exti.c rcs_uart.c rcs_can.c rcs_os.c rcs_tim.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0
