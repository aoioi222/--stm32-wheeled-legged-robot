# Keil uVision project F407Practice.uvprojx, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F407Practice
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,_FPU_PRESENT=1
  c include: ..\CORE;..\FWLIB\inc;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\uCOS-II\CONFIG;..\uCOS-II\CORE;..\uCOS-II\PORT;..\BSP;..\uCOS-II\uC-CPU;..\uCOS-II\uC-LIB;..\RCSLIB;..\USERLIB;..\RCSLIB\vesc_can_master;..\CORE\dsp;..\CORE\dsp\Include;..\CORE\dsp\Include\dsp;..\RCSLIB\Matrix_hub;..\Tri-modal robot;..\Tri-modal robot\Calculate;..\Tri-modal robot\IMU;..\Tri-modal robot\gait_controller;..\Tri-modal robot\remote_controller
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group 业务逻辑层/逻辑实现
    ./: MainTask.c ChassisTask.c UpctrlTask.c BleTask.c GpsTask.c App_Cfg.h
  group 业务逻辑层/功能实现
    ../RCSLIB/: Up_Ctrl.c Vision.c
    ./: Ch_Ctrl.c Tester.c main.c R2_CombCtrl.c
  group 业务逻辑层/中断服务
    ./: stm32f4xx_it.c system_stm32f4xx.c
  group 业务逻辑层/功能配置
    ../RCSLIB/: rcs.h
    ./: Core407_RCS12_Debug.c Core407_RCS12_PinMapping.c
  group Tri-modal robot
    ../Tri-modal robot/: Overall_contrl.c Overall_contrl.h Fly_contrl.c Fly_contrl.h Foot_mode_control.c Foot_mode_control.h Wheel_mode_contrl.c Wheel_mode_contrl.h bezier_foot_tra.c bezier_foot_tra.h robot_state.c robot_state.h Kalman_Filter.c Kalman_Filter.h body_control.c body_control.h Foot_structure.c Foot_structure.h robot_config.h include_head.h motor_LZ.h gravity_comp.h gravity_comp.c
    ../Tri-modal robot/Calculate/: Forward_kinematics_calculate.c Forward_kinematics_calculate.h Inverse_kinematics_calculate.c Inverse_kinematics_calculate.h Jacobian_matrix.c Jacobian_matrix.h
    ../Tri-modal robot/gait_controller/: gait_controller.c gait_controller.h gait_generator.c gait_generator.h gait_scheduler.c gait_scheduler.h leg_state_machine.c leg_state_machine.h
    ../Tri-modal robot/IMU/: Hardware I2C.c Hardware_I2C.h I2C_ICM_42688_P_control.c I2C_ICM_42688_P_control.h I2C_communication.c I2C_communication.h
    ../Tri-modal robot/remote_controller/: remote_control_sbus.c remote_control_sbus.h jump_controller.c jump_controller.h
  group RCSLIB/机器人功能层
    ../RCSLIB/: RCS_Motor_Upctrl.c RCS_Ctrl_BaseMove.c RCS_Actor_Upctrl.c RCS_RTOS.c RCS_Motor_Reposition.c RCS_Dribble.c
    ./: located_postion.c located_position.h
  group RCSLIB/模块驱动层
    ../RCSLIB/: RCS_AGV_BaseMove.c RCS_BaseMove.c RCS_Pwm.c RCS_ASCII.c RCS_OLED.c RCS_Types.c RCS_Interface.c Gyro.c RCS_Encoder.c GPS_Action.c Joystick_Ctrl.c Laser_Position.c Laser_Ranging.c RCS_VESC_MOTOR.c RCS_MOTOR.c G431_GPS.c RCS_DT35.c Valve_2006.c RCS_AGV.c
    ./: RCS_Debug.c stp23.c A1motor.c Linux_orangepi.c Linux_orangepi.h ax_sbus.c ax_sbus.h crc8.c crc8.h uart_comm.c uart_comm.h
  group RCSLIB/软件驱动层
    ./: FSM.c
    ../RCSLIB/: FSM_Lite.c RCS_Filter.c RCS_Ptl.c RCS_DataStructure.c RCS_PIDctrl.c RCS_Scara.c RCS_ANSI.c RCS_LogServer.c RCS_Stastic.c RCS_AcceCtrl.c Cov_AcceLimit_Ctrl.c
  group RCSLIB/外设接口层
    ../RCSLIB/: RCS_CAN_Interface.c RCS_ADC.c RCS_CAN.c RCS_DMA.c RCS_Exti.c RCS_GPIO.c RCS_Timer.c RCS_spi.c RCS_Usart.c
  group 中间件-uCOS-II
    ../uCOS-II/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../uCOS-II/PORT/: os_cpu_a.asm os_cpu_c.c
    ../uCOS-II/uC-CPU/: cpu_c.c cpu_core.c cpu_a.asm
    ../uCOS-II/uC-LIB/: lib_ascii.c lib_mem.c lib_str.c
  group 中间件-SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group BSP-STM32F4xx标准库
    ../FWLIB/src/: misc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_adc.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group BSP-uCOS
    ../BSP/: bsp.c bsp_int.c
  group BSP-CMSIS
    ../CORE/: startup_stm32f40_41xxx.s
software components: Compiler:Event Recorder 1.5.1
